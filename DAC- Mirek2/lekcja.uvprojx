# Keil uVision project lekcja.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.6.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: lekcja
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F4XX
  c include: ..\STM32F4-Discovery_FW_V1.1.0\Libraries\CMSIS\Include;..\STM32F4-Discovery_FW_V1.1.0\Libraries\CMSIS\ST\STM32F4xx\Include;..\STM32F4-Discovery_FW_V1.1.0\Libraries\CMSIS\ST\STM32F4xx\Source;..\STM32F4-Discovery_FW_V1.1.0\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\STM32F4-Discovery_FW_V1.1.0\Libraries\STM32F4xx_StdPeriph_Driver\src;..\STM32F4-Discovery_FW_V1.1.0;..\TM_Kopia\TM_DELAY;..\STM32F4-Discovery_FW_V1.1.0\HD47780
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group user
    ./: main.c
    ../STM32F4-Discovery_FW_V1.1.0/Libraries/STM32F4xx_StdPeriph_Driver/inc/: stm32f4xx_dac.h stm32f4xx_gpio.h stm32f4xx_rcc.h stm32f4xx_tim.h misc.h stm32f4xx_exti.h stm32f4xx_syscfg.h
    ../STM32F4-Discovery_FW_V1.1.0/Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_dac.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_tim.c misc.c stm32f4xx_exti.c stm32f4xx_syscfg.c
    ../STM32F4-Discovery_FW_V1.1.0/: stm32f4xx_it.c stm32f4xx_it.h
    ../STM32F4-Discovery_FW_V1.1.0/Hd44780ver2/: main.h
    ../TM_Kopia/TM_DELAY/: attributes.h stm32f4_delay.c stm32f4_delay.h
    ../STM32F4-Discovery_FW_V1.1.0/HD47780/: lcd4bit.c lcd4bit.h
software components: CMSIS:CORE 4.1.0, Device:Startup 2.4.0
