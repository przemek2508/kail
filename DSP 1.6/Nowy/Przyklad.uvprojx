# Keil uVision project Przyklad.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.6.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Przyklad
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F4XX
  c include: .\libraries\CMSIS\Include;.\libraries\STM32F4xx_StdPeriph_Driver\inc;.\inc;.\utilities;..\Nowy
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group UserCode
    ./src/: main.c stm32f4xx_it.c
  group StdPeriphDriv
    ./libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c
  group CMSIS
    ./src/: system_stm32f4xx.c
  group MDK_ARM
    ./: startup_stm32f40xx.s
