# Keil uVision project lekcja.uvprojx, settings and files
target LCD (ARM-ADS)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.6.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: lekcja
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F4XX
  c include: ..\STM32F4-Discovery_FW_V1.1.0\Libraries\CMSIS\Include;..\STM32F4-Discovery_FW_V1.1.0\Libraries\CMSIS\ST\STM32F4xx\Include;..\STM32F4-Discovery_FW_V1.1.0\Libraries\CMSIS\ST\STM32F4xx\Source;..\TM;..\TM\TM_DELAY;..\TM\TM_GPIO;..\TM\TM_STM32F4_HD44780_Library;..\STM32F4-Discovery_FW_V1.1.0\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\STM32F4-Discovery_FW_V1.1.0\Libraries\STM32F4xx_StdPeriph_Driver\src;..\STM32F4-Discovery_FW_V1.1.0
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group user
    ./: main.c
  group CMSIS
    ../STM32F4-Discovery_FW_V1.1.0/Libraries/STM32F4xx_StdPeriph_Driver/inc/: stm32f4xx_gpio.h stm32f4xx_rcc.h
    ../STM32F4-Discovery_FW_V1.1.0/Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_gpio.c stm32f4xx_rcc.c
    ../STM32F4-Discovery_FW_V1.1.0/: stm32f4xx.h
  group TM
    ../TM/TM_DELAY/: tm_stm32f4_delay.c tm_stm32f4_timer_properties.c attributes.h tm_stm32f4_delay.h tm_stm32f4_timer_properties.h
    ../TM/TM_GPIO/: tm_stm32f4_gpio.c tm_stm32f4_gpio.h
    ../TM/: defines.h
    ../TM/TM_STM32F4_HD44780_Library/: tm_stm32f4_hd44780.c tm_stm32f4_hd44780.h
software components: CMSIS:CORE 4.1.0, Device:Startup 2.4.0
