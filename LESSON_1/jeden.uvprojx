# Keil uVision project jeden.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.6.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: jeden
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F4XX
  c include: ..\..\STM32F4-Discovery_FW_V1.1.0\Libraries\CMSIS\Include;..\..\STM32F4-Discovery_FW_V1.1.0\Libraries\CMSIS\ST\STM32F4xx\Source\Templates;..\..\STM32F4-Discovery_FW_V1.1.0\Libraries\CMSIS\ST\STM32F4xx\Include;..\..\STM32F4-Discovery_FW_V1.1.0\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\STM32F4-Discovery_FW_V1.1.0;..\STM32F4-Discovery_FW_V1.1.0\Libraries\STM32_USB_OTG_Driver\src;..\STM32F4-Discovery_FW_V1.1.0\Utilities\STM32F4-Discovery
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./: main.c
    ../STM32F4-Discovery_FW_V1.1.0/Libraries/STM32F4xx_StdPeriph_Driver/inc/: stm32f4xx_gpio.h stm32f4xx_rcc.h
    ../STM32F4-Discovery_FW_V1.1.0/: stm32f4xx_it.c stm32f4xx_it.h
    ../STM32F4-Discovery_FW_V1.1.0/Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_gpio.c stm32f4xx_rcc.c
    ../STM32F4-Discovery_FW_V1.1.0/Utilities/STM32F4-Discovery/: stm32f4_discovery.h
software components: CMSIS:CORE 4.3.0, CMSIS:DSP 1.4.6, Device:Startup 2.4.0
